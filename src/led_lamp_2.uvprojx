# Keil uVision project led_lamp_2.uvprojx, settings and files
target PWM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C123GH6PM UART_BUFFERED
  c include: ..\..\CMSIS\CMSIS\Include;C:\ti\TivaWare_C_Series-2.1.4.178
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: main.c led.c cmd.c button.c common_aux.c i2c_ext.c tsl2591.c log.c timer_ext.c console.c
    C:/ti/TivaWare_C_Series-2.1.4.178/utils/: uartstdio.c
  group Libraries
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
  group Headers
    ./: led.h cmd.h button.h common_aux.h log.h i2c_ext.h tsl2591.h timer_ext.h console.h
software components: Device:Startup 1.0.1
